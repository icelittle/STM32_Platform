# Keil uVision project WATCH.uvprojx, settings and files
target WATCH (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: jumawatch
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,ENABLE_SPI_FIX,BLUENRG_MS,STM32F429xx,USE_STM32F429I_DISCO,RTC_LSE,SERVER_ROLE,NO_PRINTF,JUMA_WATCH,CANNON_V2
  c misc: --C99 --gnu
  c include: ..\inc;..\..\..\system\cmsis\include;..\..\..\system\cmsis\device\st\inc;..\..\..\system\bsp\jumawatch;..\..\..\system\hal\stm32f4xx_hal_driver\inc;..\..\..\system\drivers\juma\common;..\..\..\system\drivers\juma\ili9341;..\..\..\system\drivers\juma\st7789v;..\..\..\system\drivers\st\hts221;..\..\..\system\drivers\st\lps25h;..\..\..\system\drivers\st\lps25hb;..\..\..\system\drivers\st\lsm303agr;..\..\..\system\drivers\st\lsm6ds3;..\..\..\system\drivers\st\common;..\..\..\system\drivers\st\bluenrg\bluenrg_ms;..\..\..\system\middlewares\st\bluenrg_ms\inc;..\..\..\system\middlewares\juma\st7789v;..\..\..\system\middlewares\juma\sdk;..\..\..\system\middlewares\juma\sensor;..\..\..\system\middlewares\juma\dispatcher;..\..\..\system\middlewares\juma\low_power
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group product/jumawatch
    ../src/: app.c adc0.c fmc_nor.c
  group system
    ../src/: main.c
  group system/middlewares/st
    ../../../system/middlewares/st/bluenrg_ms/src/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c gp_timer.c hci.c list.c osal.c clock.c
  group system/middlewares/juma
    ../../../system/middlewares/juma/sdk/: bluenrg_sdk_api.c
    ../../../system/middlewares/juma/sensor/: juma_sensor.c
    ../../../system/middlewares/juma/dispatcher/: dispatch.c
    ../../../system/middlewares/juma/low_power/: stm32f401_lp_mode.c
  group system/drivers/st
    ../../../system/drivers/st/hts221/: hts221.c
    ../../../system/drivers/st/lps25hb/: lps25hb.c
    ../../../system/drivers/st/lsm6ds3/: lsm6ds3.c
    ../../../system/drivers/st/lsm303agr/: lsm303agr.c LSM303AGR_ACC_driver.c LSM303AGR_MAG_driver.c
    ../../../system/drivers/st/lps25h/: lps25h.c
    ../../../system/drivers/st/bluenrg/bluenrg_ms/: stm32_bluenrg_ble.c
  group system/drivers/juma
    ../../../system/drivers/juma/st7789v/: st7789v.c
  group system/bsp/jumawatch
    ../../../system/bsp/jumawatch/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_pressure.c bsp_isr.c bsp_common.c stm32f4xx_hal_msp.c
  group system/hal/stm32f4xx_hal_driver
    ../../../system/hal/stm32f4xx_hal_driver/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group system/cmsis
    ../../../system/cmsis/device/st/src/: startup_stm32f429xx.s system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
